# Repository reilleya/micro

## KiCad design Micro.kicad_pcb

Parts:
C1: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 10uF; CP_Elec_5x3.9
C3, C4, C5, C8, C9, C10: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C7: 2.2uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
FB1, FB2: Ferrite; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_Mini; USB_Micro-B_Molex_47346-0001
J2: Programmer; PinHeader_2x04_P2.00mm_Vertical
J3, J4, J5: Conn_01x13; PinHeader_1x13_P2.54mm_Vertical
L1: 1uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1, R2: 33; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP1, TP2: TestPoint; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: ADP2108AUJ-3.3; TSOT-23-5
U2: MK20DX256VLH7; LQFP-64_10x10mm_P0.5mm
Y1: 16 Mhz; Crystal_HC49-U_Vertical

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, FB2.1, J2.3, J3.13, L1.2, TP2.1, U1.4 (FB), U2.3, U2.7, U2.21, U2.30, U2.48
/PTA0: J2.8, U2.22
/PTA1: J2.6, U2.23
/PTA2: J2.4, U2.24
/PTA3: J2.2, U2.25
/RST: J2.1, U2.34
/USBM: R2.1, U2.6
/USBP: R1.1, U2.5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C10.2, FB1.1, J1.5 (GND), J1.6 (Shield), J2.5, J2.7, J3.12, TP1.1, U1.2 (GND), U2.4, U2.31, U2.47
unnamed: C1.1, J1.1 (VBUS), U1.1 (Vin), U1.3 (EN)
unnamed: C7.1, FB2.2, R3.2, U2.13
unnamed: C7.2, C8.2, C9.2, FB1.2, U2.15, U2.16
unnamed: C8.1, R3.1, U2.14
unnamed: C9.1, U2.17
unnamed: J1.2 (D-), R2.2
unnamed: J1.3 (D+), R1.2
unnamed: J3.1, U2.50
unnamed: J3.2, U2.58
unnamed: J3.3, U2.43
unnamed: J3.4, U2.35
unnamed: J3.5, U2.36
unnamed: J3.6, U2.38
unnamed: J3.7, U2.37
unnamed: J3.8, U2.62
unnamed: J3.9, U2.63
unnamed: J3.10, U2.44
unnamed: J3.11, U2.45
unnamed: J4.1, U2.39
unnamed: J4.2, U2.40
unnamed: J4.3, U2.57
unnamed: J4.4, U2.28
unnamed: J4.5, U2.29
unnamed: J4.6, U2.64
unnamed: J4.7, U2.61
unnamed: J4.8, U2.59
unnamed: J4.9, U2.60
unnamed: J4.10, U2.46
unnamed: J4.11, U2.49
unnamed: J4.12, U2.51
unnamed: J4.13, U2.52
unnamed: J5.1, U2.18
unnamed: J5.2, U2.11
unnamed: J5.3, U2.27
unnamed: J5.4, U2.42
unnamed: J5.5, U2.2
unnamed: J5.6, U2.54
unnamed: J5.7, U2.53
unnamed: J5.8, U2.55
unnamed: J5.9, U2.56
unnamed: J5.10, U2.1
unnamed: J5.11, U2.41
unnamed: J5.12, U2.26
unnamed: J5.13, U2.12
unnamed: L1.1, U1.5 (SW)
unnamed: U2.32, Y1.1
unnamed: U2.33, Y1.2

Board: 2 copper layers, 26 parts (0 on the bottom side), 56 nets.

## Commit log

2019-07-18 Initial version of schematic
2019-07-18 Cleaned up and set footprints
2019-07-19 Starting layout
2019-07-20 Continued routing
